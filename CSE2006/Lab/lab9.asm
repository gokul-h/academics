DATA SEGMENT
RES DB 0AH DUP(0)
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
    MOV AX,DATA
    MOV DS,AX
    MOV AL,00H
    MOV BL,01H
    LEA SI,RES
    MOV [SI],AL
    MOV CL,0AH
L1:
    ADD AL,BL
    MOV [SI],AL
    MOV AL,BL
    MOV BL,[SI]
    INC SI
    DEC CL
    CMP CL,00H
    JNZ L1
HLT
CODE ENDS
    END START
