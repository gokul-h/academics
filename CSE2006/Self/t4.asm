ASSUME CS: CODE, DS:DATA
DATA SEGMENT
	ORG 2000H
	ARR DW 0738H, 1253H, 5674H, 9273H, 0AB3H, 58C4H, 8EFAH, 32CEH, 18CDH, 842AH, 1357H, 0877H, 20E4H, 1687H, 573AH
	ORG 4000H
	COUNT DW ?
DATA ENDS

CODE SEGMENT
	START:
	MOV AX, DATA
	MOV DS, AX
	MOV SI, OFFSET ARR
	MOV AX, 0000H  
	MOV BX, 0000H
	MOV CX, 0FH  
	LO:
		MOV AX, [SI] 
		TEST AX, 03H  
		JZ LOOP1
		JMP LOOP2
		LOOP1:
		INC BX 
		JMP LOOP2
		LOOP2:
		ADD SI, 02H  
	LOOP LO
	MOV COUNT, BX 
	HLT
CODE ENDS
	END START
END
