ASSUME CS:CODE ,DS:DATA 
DATA SEGMENT  
	STRING1 DW 45,12,16,48,17,69,28,42,63,47,13,46,85,19,63,41,73,91,82,87
	SUM DW 0 
	DIVIDER DB 02 
DATA ENDS 

CODE SEGMENT 
	START: 
	MOV AX,DATA 
	MOV DS,AX 
	MOV BX,02 
	MOV CX,20 
	LEA SI,STRING1
	DOWN: MOV AX,[SI]
	INC SI 
	INC SI 
	DIV BX 
	CMP DX,01 
	JZ ODD 
	MUL BX 
	ADD SUM,AX 
	ODD: LOOP DOWN 
	MOV AX,SUM 
	MOV DI,5000H 
	MOV [DI],AL 
	MOV DI,5001H 
	MOV [DI],AH 
	HLT 
CODE ENDS 
	END START
	
	